# IAR project STM32H747I-EVAL.ewp, settings and files
configuration STM32H747I-EVAL_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_M4 ST STM32H747XI_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32H747xx; USE_BPP=24; USE_PWR_DIRECT_SMPS_SUPPLY
  ICCARM.CCIncludePath2: ../CM4/Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../CM4/Core/Inc
  OBJCOPY.OOCOutputFile: STM32H747I-EVAL_CM4.hex
  ILINK.IlinkOutputFile: STM32H747I-EVAL_CM4.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H747I-EVAL_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_M7 ST STM32H747XI_M7
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H747xx; USE_BPP=24; USE_PWR_DIRECT_SMPS_SUPPLY
  ICCARM.CCIncludePath2: ../CM7/Core/Inc; ../CM7/TouchGFX/App; ../CM7/TouchGFX/target/generated; ../CM7/TouchGFX/target; ../Drivers/BSP/Components/Common; ../Drivers/BSP/STM32H747I-EVAL; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/STM32H747I-EVAL; ../CM7/Middlewares/ST/touchgfx/framework/include
  AARM.AUserIncludes: ../CM7/Core/Inc
  OBJCOPY.OOCOutputFile: STM32H747I-EVAL_CM7.hex
  ILINK.IlinkOutputFile: STM32H747I-EVAL_CM7.out
  ILINK.IlinkIcfFile: stm32h747xx_flash_CM7.icf
  ILINK.IlinkAdditionalLibs: ../CM7/Middlewares/ST/touchgfx/lib/core/cortex_m7/IAR8.x/touchgfx_core.a
  group Application/EWARM
    ./: startup_stm32h747xx_CM4.s startup_stm32h747xx_CM7.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main_user.c main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/CM7/TouchGFX/App
    ../CM7/TouchGFX/App/: app_touchgfx.c
  group Application/User/CM7/TouchGFX/target
    ../CM7/TouchGFX/target/: STM32H7Instrumentation.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/CM7/TouchGFX/target/generated
    ../CM7/TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
    ../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
  group Drivers/BSP/STM32H747I-EVAL
    ../Drivers/BSP/STM32H747I-EVAL/: stm32h747i_eval_bus.c stm32h747i_eval_io.c stm32h747i_eval_lcd.c stm32h747i_eval_qspi.c stm32h747i_eval_sdram.c stm32h747i_eval_ts.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
